# Keil uVision project gpio_output.uvprojx, settings and files
target gpio_output_Release (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: HC32L136K8TA HDSC
  pack: HDSC.HC32L136.1.0.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: gpio_output +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 wLevel=2
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc;..\radio;..\periph
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l13x.s
    ../../../../mcu/common/: system_hc32l13x.c interrupts_hc32l13x.c
  group source
    ../source/: main.c SQ.c
  group driver
    ../../../../driver/src/: ddl.c sysctrl.c gpio.c
  group periph
    ../periph/: cmt_spi3.c
  group radio
    ../radio/: cmt2300a.c cmt2300a_hal.c radio.c
  group README
    ../: readme.txt
software components: CMSIS:CORE 5.5.0
