# Keil uVision project GD32E230C8T6.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: GD32E230C8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.2.5.0
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: GD32E230C8T6 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E230
  c include: ..\User;..\Firmware\GD32E23x_standard_peripheral\Include;..\Firmware\CMSIS\GD\GD32E23x\Include;..\Firmware\CMSIS;..\Hardware;..\wu-xian_interface;..\wu-xian-App;..\you-xian_interface;..\test-diu-bao-lv
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ../User/: gd32e23x_it.c main.c systick.c
  group Hardware
    ../Hardware/: usart.c
  group Firmware
    ../Firmware/GD32E23x_standard_peripheral/Source/: gd32e23x_adc.c gd32e23x_cmp.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_pmu.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c gd32e23x_wwdgt.c
  group CMSIS
    ../Firmware/CMSIS/GD/GD32E23x/Source/: system_gd32e23x.c
    ../test-diu-bao-lv/: startup_packet_loss.s
  group Doc
    ../Doc/: readme.txt
  group wu-xian_interface
    ../wu-xian_interface/: cmt_port.c cmt_spi3.c cmt2300a_hal.c cmt2300a.c cmt2219b.c
  group wu-xian-App
    ../wu-xian-App/: receiver_app.c receiver_app.h wireless_demo.c wireless_demo.h wireless_demo_params.h
  group you-xian_interface
    ../you-xian_interface/: wired_control.c wired_port.c wired_control.h wired_config.h
  group test-diu-bao-lv
    ../test-diu-bao-lv/: packet_loss_stats.h packet_loss_stats.c packet_loss_test.h packet_loss_test.c packet_loss_config.h
software components: CMSIS:CORE 5.6.0
