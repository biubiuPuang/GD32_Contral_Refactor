# Keil uVision project switch_test.uvprojx, settings and files
target Switch Test PB7 PB8 (6210000::V6.21::ARMCLANG)
  device: GD32E230C8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.2.5.0
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: switch_test +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E230
  c include: ..\..\User;..\..\Firmware\GD32E23x_standard_peripheral\Include;..\..\Firmware\CMSIS\GD\GD32E23x\Include;..\..\Firmware\CMSIS;..\..\Hardware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ../../User/: gd32e23x_it.c systick.c
    ./: switch_test.c
  group Hardware
    ../../Hardware/: usart.c
  group Firmware
    ../../Firmware/GD32E23x_standard_peripheral/Source/: gd32e23x_gpio.c gd32e23x_misc.c gd32e23x_rcu.c gd32e23x_usart.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32E23x/Source/: system_gd32e23x.c
    ../../Firmware/CMSIS/GD/GD32E23x/Source/ARM/: startup_gd32e23x.s
software components: CMSIS:CORE 5.6.0
